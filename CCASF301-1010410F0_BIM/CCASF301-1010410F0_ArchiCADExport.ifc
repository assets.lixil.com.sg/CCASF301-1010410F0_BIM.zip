Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-04-18T09:55:39+07:00
Written by: ODA SDAI 22.12
Made in: 23.0.11.19 - Exporter 23.0.11.19 - Alternate UI 23.0.11.19

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort (2)
Description: Flow
Name | FlowDirection
Port_301535 | SINK
Port_301535 | SOURCE

# IfcFlowTerminal: CCASF301-1010410F0_REVIT:Milano Semi-counter Top Lava, CCASF301-1010410F0_REVIT:Milano Semi-counter Top Lava:301535
In: Level 1
Type - Material: Ceramics
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_DistributionFlowElementCommon - Reference: Milano Semi-counter Top Lava; sets with these values: 2
